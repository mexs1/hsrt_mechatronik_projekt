# Keil uVision project Stufe1.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stufe1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c main.h init.c operate.c sd.c mcp2515.c mcp2515.h mcp2515_defs.h can.c can.h
  group AD Libraries
    ./: DioCfg.c SpiLib.c AdcLib.c DmaLib.c FeeLib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
